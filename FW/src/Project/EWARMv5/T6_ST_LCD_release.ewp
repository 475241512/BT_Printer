# IAR project T6_ST_LCD_release.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xx8 ST STM32F10xx8
  ICCARM.CCDefines: RELEASE_VER; LCD_VER
  ICCARM.CCIncludePath2: ..\; ..\..\App\; ..\..\Drivers\; ..\..\FatFs\; ..\..\Lib\inc\; ..\..\uCOS\uC-CPU\; ..\..\uCOS\uC-LIB\; ..\..\uCOS\uCOS-II\Ports\; ..\..\uCOS\uCOS-II\Source\; ..\..\uCOS\uC-Probe\; ..\..\usb_lib\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: T6.bin
  ILINK.IlinkOutputFile: T6.out
  ILINK.IlinkIcfFile: stm32f10x_flash _16K_bootcode.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cortexm3_macro.s stm32f10x_vector.c
    ../: main.c stm32f10x_it.c
  group App
    ../../App/: basic_fun.c DotFill.c esc_p.c ESC_POS_test.c Event.c font.c JMemory.c LED.c rec_ecc.c record_mod.c res_spi_new.c Terminal_Para_m.c
  group Drivers
    ../../Drivers/: BT816.c crc32.c data_uart.c hw_platform.c lcd.c print_head.c ringbuffer.c spi_flash.c TimeBase.c
    ../../App/: KeyScan.c PaperDetect.c ThermalDetect.c TP.c uart.c
  group Fatfs
    ../../FatFs/: diskio.c ff.c
  group FWLib
    ../../Lib/src/: hardfault_isr_handle_a.asm stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_crc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c
  group usb_lib
    ../../usb_lib/: hw_config.c mass_mal.c memory.c scsi_data.c usb_app_config.c usb_bot.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_scsi.c usb_sil.c
