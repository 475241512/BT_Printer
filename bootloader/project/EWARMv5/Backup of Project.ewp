# IAR project Backup of Project.ewp, settings and files
configuration POS-EVAL (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Full.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCIncludePath2: ..\; ..\..\library\inc\; ..\..\uCOS-II\Source\; ..\..\uCOS-II\Ports\; ..\..\uCOS-II\uC-Lib\; ..\..\uCOS-II\uC-CPU\; ..\..\uCOS-II\uC-Probe\; ..\..\driver\; ..\..\app\; ..\..\fat\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: EVAL.out
  ILINK.IlinkIcfFile: app_in0000.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group app
    ../../app/: des.c des.H misc.c misc.h once_mem.c once_mem.H rtc.h timer_manager.c timer_manager.h xmlParse.c xmlParse.H
    ../: main.c
  group Driver
    ../../driver/: hw_misc.c hw_misc.H MD5.c MD5.h sd2068.c sd2068.h sdcard.c sdcard.h TimeBase.c TimeBase.h
  group EWARMv5
    ./: cortexm3_macro.s stm32f10x_vector.c
    ../: stm32f10x_conf.h stm32f10x_it.c
  group fat
    ../../fat/: diskio.c ff.c
  group FWLib
    ../../library/src/: stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
