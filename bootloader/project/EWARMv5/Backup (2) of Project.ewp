# IAR project Backup (2) of Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xE ST STM32F103xE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCIncludePath2: ..\; ..\..\app\; ..\..\driver\; ..\..\FatFs\; ..\..\usb_lib\; ..\..\library\inc\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: E:\T5_精简版\bootloader\project\EWARMv5\stm32f10x_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: cortexm3_macro.s stm32f10x_vector.c
    ../../app/: des.c PCUsart.c
    ../../FatFs/: diskio.c ff.c
    ../../driver/: gui.c hw_misc.c lcd.c spi_flash.c
    ../: main.c stm32f10x_it.c
    ../../library/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c stm32f10x_tim.c
  group usb_lib
    ../../usb_lib/: hw_config.c mass_mal.c memory.c scsi_data.c usb_bot.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_scsi.c usb_sil.c
