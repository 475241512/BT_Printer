# IAR project Project.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxE ST STM32F10xxE
  ICCARM.CCDefines: LCD_VER; GD_MCU
  ICCARM.CCIncludePath2: ..\; ..\..\usb_lib\; ..\..\library\inc\; ..\..\FatFs\; ..\..\driver\; ..\..\app\
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: Project.bin
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: E:\BT_Printer\FW\src\Project\EWARMv5\stm32f10x_debug.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.RTConfigPath: dl-stnl0.a
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../../app/: basic_fun.c basic_fun.h des.c
    ./: cortexm3_macro.s stm32f10x_vector.c
    ../../FatFs/: diskio.c ff.c
    ../../driver/: hw_misc.c lcd.c spi_flash.c
    ../: main.c stm32f10x_it.c
    ../../library/src/: stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_lib.c stm32f10x_nvic.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_systick.c
  group usb_lib
    ../../usb_lib/: hw_config.c mass_mal.c memory.c scsi_data.c usb_app_config.c usb_bot.c usb_core.c usb_desc.c usb_endp.c usb_init.c usb_int.c usb_istr.c usb_mem.c usb_prop.c usb_pwr.c usb_regs.c usb_scsi.c usb_sil.c
