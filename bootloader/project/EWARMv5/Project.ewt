<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Debug</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <configuration>
    <name>Release</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>0</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>0</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>usb_lib</name>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\hw_config.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\mass_mal.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\memory.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\scsi_data.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_bot.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_core.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_desc.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_endp.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_init.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_int.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_istr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_mem.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_prop.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_pwr.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_regs.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_scsi.c</name>
    </file>
    <file>
      <name>$PROJ_DIR$\..\..\usb_lib\usb_sil.c</name>
    </file>
  </group>
  <file>
    <name>$PROJ_DIR$\cortexm3_macro.s</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\app\des.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\FatFs\diskio.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\FatFs\ff.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\driver\gui.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\driver\hw_misc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\driver\lcd.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\main.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\app\PCUsart.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\driver\spi_flash.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_dma.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_exti.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_flash.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_gpio.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\stm32f10x_it.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_lib.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_nvic.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_pwr.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_rcc.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_spi.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_systick.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\..\..\library\src\stm32f10x_tim.c</name>
  </file>
  <file>
    <name>$PROJ_DIR$\stm32f10x_vector.c</name>
  </file>
</project>


