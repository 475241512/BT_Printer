# Keil uVision project NUC123_USB_Printer.uvproj, settings and files
target NUC123_Printer (ARM-ADS)
  device: NUC123SD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: NUC123_USB_Printer +hex
  c flags: Optim=3 oTime=1 wLevel=2
  c include: .\LIB_Include;.\APP_Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group LIB_Source
    ./LIB_Source/: startup_NUC123Series.s NUC123_CLK_GPIO_IP_Init.c NUC_Stepmotor.lib printer.c Load_ASC16.s Nuc123_usb_1.c
  group User
    ./APP_Source/: main.c
