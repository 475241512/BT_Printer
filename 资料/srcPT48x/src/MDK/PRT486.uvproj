# Keil uVision project PRT486.uvproj, settings and files
target PRT486 (ARM-ADS)
  device: LPC1114/302 NXP
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: PRT486 +hex
  c flags: Optim=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  group src
    ../: clkconfig.c config-param.c core_cm0.c DotFill.c esc_p.c Event.c F25L016A.c font.c gpio.c KeyScan.c LED.c main.c PaperDetect.c Retarget.c SSP.c system_LPC11xx.c ThermalDetect.c timer16.c timer32.c TP.c uart.c startup_LPC11xx.s
